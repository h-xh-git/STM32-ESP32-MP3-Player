# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\app;..\..\board;..\..\bsp;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\module;..\..\bsp\uart;..\..\bsp\uart2;..\..\bsp\lcd;..\..\bsp\key;..\..\bsp\beep;..\..\bsp\ui;..\..\bsp\proto;..\..\bsp\sdio;..\..\FatFS;..\..\bsp\encoder;..\..\bsp\storage;..\..\bsp\spid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: Project_ccm.sct
  group APP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../app/: main.c playlist.c playlist.h mp3info.c mp3info.h audio_srv.c audio_srv.h lyrics.c lyrics.h cover.c cover.h play_resume.c play_resume.h netdl.c netdl.h
    ../../module/: stm32f4xx_it.c
  group STARTUP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group BSP
    ../../bsp/uart/: bsp_uart.c bsp_uart.h
    ../../bsp/uart2/: bsp_uart2.c bsp_uart2.h
    ../../bsp/lcd/: bsp_lcd.c bsp_lcd.h
    ../../bsp/key/: bsp_key.c bsp_key.h
    ../../bsp/beep/: bsp_beep.c bsp_beep.h
    ../../bsp/: bsp_tick.c bsp_tick.h
    ../../bsp/ui/: bsp_ui.c bsp_ui.h ui_font_cn14.h ui_text.h ui_font_cn14.c ui_player.c ui_player.h
    ../../bsp/proto/: bsp_proto.c bsp_proto.h
    ../../bsp/sdio/: bsp_sdio.c bsp_sdio.h
    ../../bsp/encoder/: bsp_encoder.c bsp_encoder.h
    ../../bsp/storage/: flash_slot.c flash_slot.h
    ../../bsp/spid/: bsp_spid.c bsp_spid.h
  group FatFs
    ../../FatFS/: ff.c ff.h ffconf.h ffunicode.c diskio.c diskio.h
  group Board
    ../../board/: board.c
  group Driver
    ../../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
